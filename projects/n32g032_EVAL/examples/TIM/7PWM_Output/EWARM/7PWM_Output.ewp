# IAR project 7PWM_Output.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G032C8 Nations N32G032C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G032; USE_STDPERIPH_DRIVER; SYSCLK_SRC=SYSCLK_USE_HSI_PLL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g032_std_periph_driver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 7PWM_Output.bin
  ILINK.IlinkOutputFile: 7PWM_Output.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g032.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g032_std_periph_driver/src/: n32g032_comp.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g032_EWARM.S
  group STARTUP/FWLB
    ../../../../../../firmware/n32g032_std_periph_driver/src/: misc.c n32g032_adc.c n32g032_beeper.c n32g032_can.c n32g032_crc.c n32g032_dbg.c n32g032_dma.c n32g032_exti.c n32g032_flash.c n32g032_gpio.c n32g032_hdiv.c n32g032_i2c.c n32g032_iwdg.c n32g032_lptim.c n32g032_lpuart.c n32g032_opamp.c n32g032_pwr.c n32g032_rcc.c n32g032_rtc.c n32g032_spi.c n32g032_sqrt.c n32g032_tim.c n32g032_tsc.c n32g032_usart.c n32g032_wwdg.c
  group USER
    ../src/: main.c n32g032_it.c

# IAR project ALGO_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G032R8 Nations N32G032R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G032; _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER; __IAR_ARM
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g032_std_periph_driver\inc; ..\..\..\..\bsp\inc; ..\..\..\..\..\..\firmware\n32g032_algo_lib\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ALGO_Demo.bin
  ILINK.IlinkOutputFile: ALGO_Demo.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\firmware\n32g032_algo_lib\lib\n32g032_aes.lib; ..\..\..\..\..\..\firmware\n32g032_algo_lib\lib\n32g032_algo_common.lib; ..\..\..\..\..\..\firmware\n32g032_algo_lib\lib\n32g032_rng.lib; ..\..\..\..\..\..\firmware\n32g032_algo_lib\lib\n32g032_sm4.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ALGO
    ../../../../../../firmware/n32g032_algo_lib/lib/: n32g032_aes.lib n32g032_algo_common.lib n32g032_rng.lib n32g032_sm4.lib
  group BSP
    ../../../../bsp/src/: log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g032.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g032_std_periph_driver/src/: misc.c n32g032_gpio.c n32g032_rcc.c n32g032_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g032_EWARM.S
  group USER
    ../src/: main.c n32g032_it.c

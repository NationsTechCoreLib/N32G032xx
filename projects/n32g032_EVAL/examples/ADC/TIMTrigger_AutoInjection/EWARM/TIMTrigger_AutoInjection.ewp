# IAR project TIMTrigger_AutoInjection.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G032C8 Nations N32G032C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G032; USE_STDPERIPH_DRIVER; SYSCLK_SRC=SYSCLK_USE_HSI_PLL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g032_std_periph_driver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIMTrigger_AutoInjection.bin
  ILINK.IlinkOutputFile: TIMTrigger_AutoInjection.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g032.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g032_std_periph_driver/src/: misc.c n32g032_adc.c n32g032_dma.c n32g032_gpio.c n32g032_rcc.c n32g032_tim.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g032_EWARM.S
  group USER
    ../src/: main.c n32g032_it.c
